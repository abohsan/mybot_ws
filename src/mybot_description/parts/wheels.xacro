Commit message: second :)

File: src/mybot_description/parts/wheels.xacro (robot description, xacro)
@@ -22,5 +22,5 @@
         izz=".1"/>
     </inertial>
-  </link>
+</link>
     <link name="left_wheel_1">
     <collision name="collision">
